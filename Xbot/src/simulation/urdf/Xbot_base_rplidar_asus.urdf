Commit message: urdf 修正

File: Xbot/src/simulation/urdf/Xbot_base_rplidar_asus.urdf (robot description, URDF)
Before this commit: robot xbot, 16 links, 15 joints
Joints:
- joint base_to_camera_platform: origin xyz=0.105 0.025 0.1 rpy=0 0 0 -> xyz=0.08 0.0 0.1 rpy=0 0 0
